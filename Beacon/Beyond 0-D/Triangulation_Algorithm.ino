 
struct Point {
  float x, y;
};

struct Line {
  Point p1, p2;
};

float[] cowPos = {-20,-20};
float[] beacon1 = {0,0};
float[] beacon2 = {30,0};
float[] beacon3 = {30,-40};

float stdDev = 3;
float meanErr = 0;

float devErr = random(1,3)*stdDev + meanErr;

float guessErr = 100;

float[] X = {4,2};

void setup() {
  Serial.begin(115200);

  float dist1 = elemSum(pointSqr(pointSub(cowPos, beacon1, 2),2)+sq(devErr);
  float dist2 = elemSum(pointSqr(pointSub(cowPos, beacon2, 2),2)+sq(devErr);
  float dist3 = elemSum(pointSqr(pointSub(cowPos, beacon3, 2),2)+sq(devErr);

  float[] dist = {dist1, dist2, dist3};

  while(guessErr > 0.5){

    float f1 = elemSum(pointSqr(pointSub(X, beacon1, 2),2);
    float f2 = elemSum(pointSqr(pointSub(X, beacon2, 2),2);
    float f3 = elemSum(pointSqr(pointSub(X, beacon3, 2),2);

    float[] f = {f1, f2, f3};

    f = pointSub(dist, f, 3);

    float[][] A = {coefMult(pointSub(X, beacon1, 2),2,2), coefMult(pointSub(X, beacon2, 2),2,2), coefMult(pointSub(X, beacon3, 2),2,2)};

    float[][] transA = matrixTranspose(A, 2, 3);

    float[][] dX = matrixMult(transA, 3, 2, A, 2, 3);
    dX = matrixInvert(dX);
    dX = matrixMult(dX, 2, 2, transA, 3, 2);
    dX = matrixMult(dX, 2, 2, f, 3, 1);

    guessErr = elemSum(pointSqr(dX, 2));

    X = pointAdd(X, dX, 2);
    
  }

}

void loop() {
  // put your main code here, to run repeatedly:

}

float[] pointSub(float[] v1, float[] v2, int elems){

  float[elems] v;

  for(int i=0; i<elems; i++){
    v[elems] = v1[elems]-v2[elems];
  }
  
  return v;
  
}

float[] pointAdd(float[] v1, float[] v2, int elems){

  float[elems] v;

  for(int i=0; i<elems; i++){
    v[elems] = v1[elems]+v2[elems];
  }
  
  return v;
  
}

float[] pointSqr (float[2] v){
  v[0] = v[0]*v[0];
  v[1] = v[1]*v[1];
  return v;
}

float elemSum(float[] v, int elems){
  
  float sum;

  for(int i=0; i<elems; i++){
    sum = sum+v[elems];
  }

  return sum;
  
}

float[] coefMult(float[] v, int elems, float coef){

  float[elems] vMult;

  for(int i=0; i<elems; i++){
    vMult[elems] = v[elems] * coef;
  }

  return vMult;
  
}

float[][] matrixTranspose(float[][] v, int Xelems, int Yelems){

  float[Yelems][Xelems] vTrans;

  for(int i=0; i<Xelems; i++){
    for(int j=0; j<Yelems; j++){
      vTrans[i][j] = v[j][i];
    }
  }

  return vTrans;
  
}

float[][] matrixInvert(float[][] v){

  float[2][2] vInvert;

  float coef = 1/((v[0][0]*v[1][1])-(v[0][1]*v[1][0]));

  vInvert[0][0] = v[1][1]*coef;
  vInvert[0][1] = -v[0][1]*coef;
  vInvert[1][0] = -v[1][0]*coef;
  vInvert[1][1] = v[0][0]*coef;

  return vInvert;
    
}

float[][] matrixMult(float[][] v1, int v1Xelems, int v1Yelems, float[][] v2, int v2Xelems, int v2Yelems){

  float[v1Xelems][v2Yelems] vMult;

  for(int i=0; i<v1Yelems; i++){
    for(int j=0; j<v2Xelems; j++){
      vMult[i][j] = 0;
      for(int k=0; k<v1Xelems; k++){
        vMult[i][j] = vMult[i][j]+(v1[k][i]*v2[j][k]);
      }
    }
  }

  return vMult;
  
}
